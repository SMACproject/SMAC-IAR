# IAR project test.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Source\hal\common; Source\hal\include; Source\hal\target\cc2530eb; Source\hal\target\components\basicrf; cpu\cc253x\dev; cpu\cc253x
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
configuration sensor_side (8051, debug)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration pc_side (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: cpu\cc253x\dev; cpu\cc253x; Source\hal\common; Source\hal\include; Source\hal\target\cc2530eb; Source\hal\target\components\basicrf
  group (top)
    ./: main_pc.c main_sensor.c
  group cpu/cc253x
    cpu/cc253x/: cc253x.h compiler.h
  group cpu/cc253x/dev
    cpu/cc253x/dev/: adc.c adc.h ads8320.c ads8320.h basic_rf.c basic_rf.h bin_cnst.h clock.c clock.h hal_assert.c hal_assert.h hal_button.c hal_button.h hal_cc8051.h hal_defs.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_types.h lis331dlh.c lis331dlh.h mpl115a.c mpl115a.h pwr_mode_manager.c pwr_mode_manager.h rf_pack.c rf_pack.h spi_manager.c spi_manager.h timer1.c timer1.h uart_manager.c uart_manager.h util.c util.h util_lcd.c util_lcd.h
