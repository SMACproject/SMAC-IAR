# IAR project Backup of test.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Source\hal\common; Source\hal\include; Source\hal\target\cc2530eb; Source\hal\target\components\basicrf
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group Board
    Source/hal/target/CC2530EB/: hal_board.c hal_board.h hal_rf.c util.c util.h util_lcd.c
  group Mcu
    Source/hal/target/components/basicrf/: basic_rf.c basic_rf.h
    Source/hal/target/CC2530EB/: hal_assert.c hal_assert.h hal_cc8051.h hal_defs.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.h hal_types.h
  group Periph
    Source/hal/target/CC2530EB/: adc.c adc.h ads8320.c ads8320.h bin_cnst.h clock.c clock.h hal_button.c lis331dlh.c lis331dlh.h mpl115a.c mpl115a.h pwr_mode_manager.c pwr_mode_manager.h rf_pack.c rf_pack.h spi_manager.c spi_manager.h timer1.c timer1.h
